# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\APP\key;.\Public;.\APP\exti;.\Libraries\STM32F10x_StdPeriph_Driver\src;.\APP\device;.\APP\esp8266;.\User;.\APP\sht30
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c user_timer.c user_timer.h
    ./APP/sht30/: user_iic.c user_iic.h
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_rtc.c
    ../../项目程序/项目雏形3/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_dbgmcu.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/led/: led.c
    ./APP/key/: key.c key.h
    ./APP/exti/: exti.c exti.h
    ./Public/: user_ili9341_lcd.c user_ili9341_lcd.h
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_fsmc.c
    ./APP/device/: device.c device.h
    ./APP/esp8266/: esp8266.c esp8266.h
    ./APP/sht30/: sht30.c sht30.h
  group PUBLIC
    ./Public/: system.c system.h SysTick.c SysTick.h usart.c usart.h dht11.c dht11.h user_usart.c user_usart.h user_rtc.c
